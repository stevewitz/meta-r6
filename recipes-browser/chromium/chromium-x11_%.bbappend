FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
PACKAGECONFIG += "component-build"
